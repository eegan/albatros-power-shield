# Repository eegan/albatros-power-shield (continued)

## KiCad design Adafruit SMT Datalogger Shield rev C.kicad_pcb

Parts:
B1: CR1220
C1, C6, C8: 10uF; 0805-NO
C5, C7: 0.1uF; 0805-NO
CN1: 1X4-CLEANBIG; 1X04-CLEANBIG
FID1, FID3: FIDUCIAL_1MM
IC1: PCF8523T; SOIC8_150MIL
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
JP2: HEADER-1X2ROUND; 1X02_ROUND
JP5: HEADER-1X1ROUND; 1X01_ROUND
LED1, LED3: red; CHIPLED_0805_NOOUTLINE
LED2, LED4: green; CHIPLED_0805_NOOUTLINE
M1: ARDUINO_R3_ICSP_NODIM; ARDUINOR3_ICSP_NODIM
R1, R2, R5, R8: 10K; 0805-NO
R3, R4, R6, R7, R10, R11: 1k; 0805-NO
R9, R12, R13, R14: 390; 0805-NO
RESET1: Reset; EVQ-Q2_SMALLER
SJ1, SJ2, SJ3, SJ4, SJ5: SOLDERJUMPER; SOLDERJUMPER_ARROW_NOPASTE
SJ6: SOLDERJUMPERCLOSED; SOLDERJUMPER_CLOSEDWIRE
SJ7: SOLDERJUMPER_2WAY; SOLDERJUMPER_2WAY_OPEN_NOPASTE
U1: TLP3543; DIP-6_W7.62mm
U2: 4050; SOIC16
U3: MIC5225-3.3; SOT23-5
U4: INA138; SOT-23-5
U$2: SDMMC06132; 06132
Y1: 32.768kHz; CRYSTAL_8X3.8

Connections:
+3V3: C7.1, C8.1, CN1.4, R7.2, SJ7.3, U2.1 (VCC), U3.5 (OUT), U$2.4 (VDD)
+5V: C5.1, C6.1, M1.5V, M1.5V_ICSP (5V@1), SJ7.1, U3.1 (IN), U3.3 (EN), U4.5 (V+)
/D10: M1.D10, SJ6.1
/D11: M1.D11, SJ5.1
/D12: M1.D12, SJ4.1
/D13: M1.D13, SJ3.1
/LOAD_ON: M1.D5, R9.2
/MISO: M1.MISO, SJ4.2, U$2.7 (DATA_OUT)
/MOSI: M1.MOSI, SJ5.2, U2.3 (1A)
/RESET: M1.RESET (/RESET), M1.RESET_ICSP (RST), RESET1.A, RESET1.A' (P1)
/SCK: M1.SCK, R6.2, SJ3.2, U2.7 (3A)
/SCL: IC1.6 (SCL), M1.SCL, R1.2, SJ2.1
/SDA: IC1.5 (SDA), M1.SDA, R2.2, SJ1.1
/SD_CS: JP5.1, R5.2, SJ6.2, U2.9 (4A)
/SD_CSIN: U2.10 (4Y), U$2.1 (CS)
/SD_DATAIN: U2.2 (1Y), U$2.2 (DATA_IN)
/SD_SCKIN: U2.6 (3Y), U$2.5 (SCLK)
/SQW: CN1.3, IC1.7 (~INT1/CLK)
GND: B1.-, C1.2, C5.2, C6.2, C7.2, C8.2, IC1.4 (VSS), J1.1, LED1.C, LED2.C, LED3.C, LED4.C, M1.GND, M1.GND@1 (GND@2), M1.GND@2 (GND@3), M1.GND@3 (GND@1), R13.1, R14.1, RESET1.B (S), RESET1.B' (S1), U1.2, U2.8 (GND), U3.2 (GND), U4.2 (GND), U$2.3 (VSS1), U$2.6 (VSS2), U$2.GP (GND), U$2.GP3 (COMMON_SW)
unnamed: B1.+$1 (+), B1.+$2 (+), IC1.3 (VBAT)
unnamed: C1.1, IC1.8 (VDD), R8.1
unnamed: CN1.1, U$2.CD (CARD_DETECT)
unnamed: CN1.2, U$2.WP (WRITE_PROTECT)
unnamed: IC1.1 (XI), Y1.P$4 (2)
unnamed: IC1.2 (XO), Y1.P$1 (1)
unnamed: J1.2, R10.1
unnamed: J1.3, R11.1
unnamed: J2.1, U1.4, U1.6
unnamed: J2.2, U1.5
unnamed 37: U4.3 (+); also elsewhere on the board
unnamed 38: R12.2, U4.4 (-); also elsewhere on the board
unnamed: JP2.1, R4.1
unnamed: JP2.2, R3.2
unnamed: LED1.A, R4.2
unnamed: LED2.A, R3.1
unnamed: LED3.A, R6.1
unnamed: LED4.A, R7.1
unnamed: M1.A0, R14.2, U4.1
unnamed: M1.A1, R12.1, R13.2
unnamed: M1.A4 (A4/SDA), SJ1.2
unnamed: M1.A5 (A5/SCL), SJ2.2
unnamed: M1.D6, R11.2
unnamed: M1.D7, R10.2
unnamed: R9.1, U1.1
VDDIO: M1.IOREF, R1.1, R2.1, R5.1, R8.2, SJ7.2

Notes on the sheet:
TODO: Get rid of extra ICSP connector on Arduino FP; 5V routing is ripped up Check SDA/SDL on Arduino symbol (we rerouted it). For some reason the netname isn't agreeing but at least SDA seems connected.
(Earlier) TODO * Look at http://wiki.dragino.com/index.php?title=Lora_Shield#Pin_Mapping_and_Unused_Pins to make compatible with LoRA shield. * Put pins for jumpering. * Add a couple more photomos switches * Add breakout for AREF, analog inputs. * Add breakout for all 3 (additional) serial ports * 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
Logger shield for Arduino
Released under CC 2.5, Attrib/Share-Alike
http://www.ladyada.net/make/logshield
To add: Analog A3-0 connections: goal is to measure 2 currents and 2 voltages Possible other analog inputs (single ended?) Check how I2C works, now (is A4/A5 used? does it need to be?) Note, differential inputs with programmable gain are ADC3-0 (A3-A0), ADC11-9 Check https://www.arduino.cc/referenc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
Shunt 1-2 V1 2 V2 3 For monitoring a 24V battery

Board: 2 copper layers, 94.0 x 53.3 mm, 49 parts (0 on the bottom side), 45 nets.

Other parts of the board:
J4: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical

Their connections:
unnamed 37: J4.1; also elsewhere on the board
unnamed 38: J4.2; also elsewhere on the board

## Commit log

2019-10-03 initial commit after converting from Eagle CAD
2019-10-03 Deleted the prototyping area
2019-10-04 before renaming net ...
2019-10-04 Fixed net name on SCL & SDA trace added a couple of vias and cleaned up traces
2019-10-19 Added Arduino MEGA files for reference.
2019-10-22 Modify .gitignore to include rescue lib
2019-10-22 Extend board outline and add 8 pin inline header for Tx/Rx UART lines
2019-11-20 Add TODO list to SCH file
2020-02-20 whatever changes I made
2020-02-20 a little cleanup; add current/voltage monitor and MAX232 to SCH
2020-03-04 Completed arduino mega power shield
2020-03-04 Cleanup with Eamon and Nivek before ordering
2020-03-04 Add dimensions
2020-03-04 Remove right-hand tab tomake the board less than 100mm long.
2020-03-11 Filled in some component data fields
2020-03-12 Moved the kicad import of the Adafruit Shield to its own directory
2020-03-12 Added component details
