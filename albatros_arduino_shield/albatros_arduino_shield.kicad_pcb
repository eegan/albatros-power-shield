# Repository eegan/albatros-power-shield

## KiCad design albatros_arduino_shield/albatros_arduino_shield.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3000_1x12mm; MPN 3000
C1: C; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1: PCF8523T; SOIC-8_3.9x4.9mm_P1.27mm
Y1: Crystal_GND23; Crystal_SMD_Abracon_ABS25-4Pin_8.0x3.8mm

Connections:
+5V: C1.1, U1.8 (VDD); also elsewhere on the board
/arduino_mega/SCL: U1.6 (SCL); also elsewhere on the board
/arduino_mega/SDA: U1.5 (SDA); also elsewhere on the board
GND: BT1.2 (-), C1.2, U1.4 (VSS); also elsewhere on the board
unnamed: BT1.1 (+), U1.3 (VBAT)
unnamed: U1.1 (OSCI), Y1.4
unnamed: U1.2 (OSCO), Y1.1

Notes on the sheet:
Keystone 3000: 12mm diam., CR1216

Parts:
J1: Conn_01x03; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical; MPN AE-6410-03A
J2: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical; MPN AE-6410-02A
R5, R6, R7, R8, R9, R10, R20, R21: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U2, U3: INA138; SOT-23-5

Connections:
+3V3: U2.5 (V+), U3.5 (V+); also elsewhere on the board
/arduino_mega/A0: R9.2, R10.1; also elsewhere on the board
/arduino_mega/A1: R21.1, U3.1; also elsewhere on the board
/arduino_mega/A2: R5.2, R6.1; also elsewhere on the board
/voltage_current_meas/A0: R20.1, U2.1; also elsewhere on the board
/voltage_current_meas/A1: R7.2, R8.1; also elsewhere on the board
GND: R6.2, R8.2, R10.2, R20.2, R21.2, U2.2 (GND), U3.2 (GND); also elsewhere on the board
unnamed: J1.1, U2.3 (+)
unnamed: J1.2, R7.1, U2.4 (-)
unnamed: J1.3, R5.1
unnamed: J2.1, U3.3 (+)
unnamed: J2.2, R9.1, U3.4 (-)

Parts:
C2, C3, C4, C5, C6: C; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J3, J4: Conn_01x03; Molex_KK-254_AE-6410-03A_1x03_P2.54mm_Vertical; MPN AE-6410-03A
JP5, JP6, JP7, JP8: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
U4: MAX232; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+3V3: C3.1, U4.16 (VCC); also elsewhere on the board
/arduino_mega/RX2: JP7.1 (A); also elsewhere on the board
/arduino_mega/RX3: JP8.1 (A); also elsewhere on the board
/arduino_mega/TX2: JP5.1 (A); also elsewhere on the board
/arduino_mega/TX3: JP6.1 (A); also elsewhere on the board
GND: C3.2, C5.2, C6.2, J3.3, J4.3, U4.15 (GND); also elsewhere on the board
unnamed: C2.1, U4.1 (C1+)
unnamed: C2.2, U4.3 (C1-)
unnamed: C4.1, U4.4 (C2+)
unnamed: C4.2, U4.5 (C2-)
unnamed: C5.1, U4.6 (VS-)
unnamed: C6.1, U4.2 (VS+)
unnamed: J3.1, U4.14 (T1OUT)
unnamed: J3.2, U4.13 (R1IN)
unnamed: J4.1, U4.7 (T2OUT)
unnamed: J4.2, U4.8 (R2IN)
unnamed: JP5.2 (B), U4.11 (T1IN)
unnamed: JP6.2 (B), U4.10 (T2IN)
unnamed: JP7.2 (B), U4.12 (R1OUT)
unnamed: JP8.2 (B), U4.9 (R2OUT)

Parts:
J5, J6: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical; MPN AE-6410-02A
JP1, JP2, JP3, JP4: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R11, R12, R13, R14, R15, R16: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
+5V: R12.1, R15.1; also elsewhere on the board
/arduino_mega/RX1: JP2.1 (A); also elsewhere on the board
/arduino_mega/RX2: JP4.1 (A); also elsewhere on the board
/arduino_mega/TX1: JP1.1 (A); also elsewhere on the board
/arduino_mega/TX2: JP3.1 (A); also elsewhere on the board
GND: R13.2, R16.2; also elsewhere on the board
unnamed: J5.1, JP2.2 (B), R11.2
unnamed: J5.2, R12.2, R13.1
unnamed: J6.1, JP4.2 (B), R14.2
unnamed: J6.2, R15.2, R16.1
unnamed: JP1.2 (B), R11.1
unnamed: JP3.2 (B), R14.1

Parts:
C11, C12: C; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1: LED_ALT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J10: SD_Card; SD_TE_2041021
R1: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U8: 4050; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C11.1, C12.1, J10.4 (VDD), U8.1 (VCC); also elsewhere on the board
/arduino_mega/SPI_CS: U8.14; also elsewhere on the board
/arduino_mega/SPI_MISO: J10.7 (DAT0); also elsewhere on the board
/arduino_mega/SPI_MOSI: U8.11; also elsewhere on the board
/arduino_mega/SPI_SCK: R1.2, U8.9; also elsewhere on the board
GND: C11.2, C12.2, D1.1 (K), J10.3 (VSS), J10.6 (VSS), J10.12 (SHELL1), J10.13 (SHELL2), U8.8 (VSS); also elsewhere on the board
unnamed: D1.2 (A), R1.1
unnamed: J10.1 (CD/DAT3), U8.15
unnamed: J10.2 (CMD), U8.12
unnamed: J10.5 (CLK), U8.10

Parts:
J7, J8, J9: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical; MPN AE-6410-02A
R17, R18, R19: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U5, U6, U7: TLP3543; DIP-6_W7.62mm

Connections:
/arduino_mega/SWITCH_1: R17.2; also elsewhere on the board
/arduino_mega/SWITCH_2: R18.2; also elsewhere on the board
/arduino_mega/SWITCH_3: R19.2; also elsewhere on the board
GND: U5.2, U6.2, U7.2; also elsewhere on the board
unnamed: J7.1, U5.4, U5.6
unnamed: J7.2, U5.5
unnamed: J8.1, U6.4, U6.6
unnamed: J8.2, U6.5
unnamed: J9.1, U7.4, U7.6
unnamed: J9.2, U7.5
unnamed: R17.1, U5.1
unnamed: R18.1, U6.1
unnamed: R19.1, U7.1

Notes on the sheet:
Max current on datasheet is 4A for "A Connection" We are using "C Connection" with 1/2 the voltage drop, since both MOSFETs are in parallel. Therefore we may be able to switch up to 8A.

Parts:
C7, C8, C9, C10: C; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J11: Conn_01x02; Molex_KK-254_AE-6410-02A_1x02_P2.54mm_Vertical; MPN AE-6410-02A
P1: Digital; Socket_Strip_Arduino_2x18
P2: Power; Socket_Strip_Arduino_1x08
P3, P4: Analog; Socket_Strip_Arduino_1x08
P5: PWM; Socket_Strip_Arduino_1x10
P6: PWM; Socket_Strip_Arduino_1x08
P7: Communication; Socket_Strip_Arduino_1x08
P10, P11, P13: CONN_01X01; Arduino_1pin
R3, R4: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; SW_SPST_B3U-1000P
U9: AP2204K-3.3; SOT-23-5

Connections:
+3V3: C9.1, C10.1, U9.5 (VOUT); also elsewhere on the board
+5V: C7.1, C8.1, J11.1, P1.35, P1.36, P2.5, R3.1, R4.1, U9.1 (VIN), U9.3 (EN); also elsewhere on the board
/arduino_mega/5(**): P6.3
/arduino_mega/6(**): P6.2
/arduino_mega/7(**): P6.1
/arduino_mega/22: P1.33
/arduino_mega/23: P1.34
/arduino_mega/24: P1.31
/arduino_mega/25: P1.32
/arduino_mega/26: P1.29
/arduino_mega/27: P1.30
/arduino_mega/28: P1.27
/arduino_mega/29: P1.28
/arduino_mega/30: P1.25
/arduino_mega/31: P1.26
/arduino_mega/32: P1.23
/arduino_mega/33: P1.24
/arduino_mega/34: P1.21
/arduino_mega/35: P1.22
/arduino_mega/36: P1.19
/arduino_mega/37: P1.20
/arduino_mega/38: P1.17
/arduino_mega/39: P1.18
/arduino_mega/40: P1.15
/arduino_mega/41: P1.16
/arduino_mega/42: P1.13
/arduino_mega/43: P1.14
/arduino_mega/44: P1.11
/arduino_mega/45: P1.12
/arduino_mega/46: P1.9
/arduino_mega/47: P1.10
/arduino_mega/48: P1.7
/arduino_mega/49: P1.8
/arduino_mega/A0: P3.1; also elsewhere on the board
/arduino_mega/A1: P3.2; also elsewhere on the board
/arduino_mega/A2: P3.3; also elsewhere on the board
/arduino_mega/AREF: P5.3
/arduino_mega/RX1: P7.6; also elsewhere on the board
/arduino_mega/RX2: P7.4; also elsewhere on the board
/arduino_mega/RX3: P7.2; also elsewhere on the board
/arduino_mega/SCL: P5.1, R3.2; also elsewhere on the board
/arduino_mega/SDA: P5.2, R4.2; also elsewhere on the board
/arduino_mega/SPI_CS: P1.4; also elsewhere on the board
/arduino_mega/SPI_MISO: P1.5; also elsewhere on the board
/arduino_mega/SPI_MOSI: P1.6; also elsewhere on the board
/arduino_mega/SPI_SCK: P1.3; also elsewhere on the board
/arduino_mega/SWITCH_1: P6.4; also elsewhere on the board
/arduino_mega/SWITCH_2: P6.5; also elsewhere on the board
/arduino_mega/SWITCH_3: P6.6; also elsewhere on the board
/arduino_mega/TX1: P7.5; also elsewhere on the board
/arduino_mega/TX2: P7.3; also elsewhere on the board
/arduino_mega/TX3: P7.1; also elsewhere on the board
/arduino_mega/Vin: P2.8
/voltage_current_meas/A0: P3.5; also elsewhere on the board
/voltage_current_meas/A1: P3.4; also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, J11.2, P1.1, P1.2, P2.6, P2.7, P5.4, SW1.1, U9.2 (GND); also elsewhere on the board
unnamed: P2.3, SW1.2

Notes on the sheet:
Shield for Arduino Mega Rev 3

Board: 2 copper layers, 99.1 x 53.3 mm, 74 parts (10 on the bottom side), 65 nets.
